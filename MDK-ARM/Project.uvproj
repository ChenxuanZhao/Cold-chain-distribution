# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../../Project;../Core/Inc;../Hardware/DHT22/Inc;../Hardware/SIM900A/Inc;../Middlewares/lib-code/Core/Inc
  group Application/MDK-ARM
    ./: STARTUP.A51 Conf_tny.A51
  group Application/User/Core
    ../Core/Src/: main.c usart.c
  group Hardware/DHT22
    ../Hardware/DHT22/Src/: DHT22.c
  group Hardware/SIM900A
    ../Hardware/SIM900A/Src/: GSM.c
  group Middlewares/lib-code
    ../Middlewares/lib-code/Core/Lib/: lib-code.LIB
